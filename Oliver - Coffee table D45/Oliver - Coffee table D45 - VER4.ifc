Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Oliver - Coffee table D45 - VER4.ifc
Time: 2024-01-12T10:52:51
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (14)
Name
 | Oliver - Coffee table D45 MODEL_0 - ObjectType: SketchupGroup
 | Oliver - Coffee table D45 MODEL_1 - ObjectType: SketchupGroup
 | Oliver - Coffee table D45 MODEL_2 - ObjectType: SketchupGroup
 | Oliver - Coffee table D45 MODEL_3 - ObjectType: SketchupGroup
 | Oliver - Coffee table D45 MODEL_4 - ObjectType: SketchupGroup
 | Oliver - Coffee table D45 MODEL_5 - ObjectType: SketchupGroup
 | Oliver - Coffee table D45 MODEL_6 - ObjectType: SketchupGroup
 | Oliver - Coffee table D45 MODEL_7 - ObjectType: SketchupGroup
 | Oliver - Coffee table D45 MODEL_8 - ObjectType: SketchupGroup
 | Oliver - Coffee table D45 MODEL_9 - ObjectType: SketchupGroup
 | Oliver - Coffee table D45 MODEL_10 - ObjectType: SketchupGroup
 | Oliver - Coffee table D45 MODEL_11 - ObjectType: SketchupGroup
 | Oliver - Coffee table D45 MODEL_12 - ObjectType: SketchupGroup
 | Oliver - Coffee table D45 MODEL_13 - ObjectType: SketchupGroup
